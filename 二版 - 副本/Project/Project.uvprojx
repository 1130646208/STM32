# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\OfficialLib;..\PersonalLib;..\Project;..\HARDWARE\HX711;..\HARDWARE\INFRARED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\SMOKE;..\HARDWARE\WATER;..\HARDWARE;..\HARDWARE\BLUETOOTH
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group OfficialLib
    ../OfficialLib/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group PersonalLib
    ../PersonalLib/: doing.c
  group Project
    ./: main.c
    ../PersonalLib/: Project.lib
  group HARDWARE
    ../HARDWARE/HX711/: hx711.c
    ../HARDWARE/INFRARED/: infrared.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c myiic.c
    ../HARDWARE/SMOKE/: smoke.c
    ../HARDWARE/WATER/: water.c
    ../HARDWARE/: test1.c showSystem.c pub_timer.c myitoa.c dataSum.c
    ../HARDWARE/BLUETOOTH/: Usart2.c flash.c
