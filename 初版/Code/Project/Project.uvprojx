# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\OfficialLib;..\PersonalLib;..\Project;..\HARDWARE\BLUETOOTH;..\HARDWARE\HX711;..\HARDWARE\INFRARED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\SMOKE;..\HARDWARE\WATER;..\PersonalLib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group OfficialLib
    ../OfficialLib/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group PersonalLib
    ../PersonalLib/: CircularQueue.c Delay.c Timer.c Task.c LowPower.c RTC.c Lock.c Usart2.c Usart1.c Usart.c BC26TX.c BC26RX.c SystemInit.c BC26CheckTask.c BC26IPCheckTask.c BC26CardCheckTask.c BC26PSMSetTask.c BC26MQTTInitTask.c flash.c BC26OpenTask.c BC26ConnectTask.c BC26SubTask.c BC26UnsubTask.c BC26PubTask.c BC26.c BT.c
    ./: test1.c
  group Project
    ./: main.c
  group HARDWARE
    ../HARDWARE/HX711/: hx711.c myiic.c
    ../HARDWARE/INFRARED/: infrared.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/SMOKE/: smoke.c
    ../HARDWARE/WATER/: water.c
    ../PersonalLib/: dataSum.c
    ./: pub_timer.c myitoa.c showSystem.h showSystem.c
